# Keil uVision project rec.uvproj, settings and files
target rec (MCS-51)
  device: C8051F330 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x1FFF) CLOCK(25000000)
  output: jiujing_rec +hex
  c flags: Optimize=8
  c include: ..\include;..\SYS;..\app;..\Flash;..\lcd_drv;..\RF;..\其他平台主机控制程序
  group app
    ../app/: main.c
  group DRV
    ../RF/: dali_drv.c
    ../app/: key_scan.c
    ../lcd_drv/: lcd_drv.c
  group SYS
    ../SYS/: system.c
  group flash
    ../Flash/: F410_FlashPrimitives.c F410_FlashUtils.c
  group SPISecure
    ../其他平台主机控制程序/: spicom_in.c spicom.c
